# IAR project pxxTH.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\; ..\..\StdPeriph\inc\
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: ..\; ..\..\StdPeriph\inc
  OBJCOPY.OOCOutputFile: pxxTH.hex
  ILINK.IlinkOutputFile: pxxTH.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  group pxxTH
    ../: main.c main.h stm8s_conf.h stm8s_it.c stm8s_it.h TH_ds18b20.c TH_ds18b20.h TH_ht1621.c TH_ht1621.h TH_htu21.c TH_htu21.h TH_key.c TH_key.h TH_lcd.c TH_lcd.h TH_uart.c TH_uart.h
  group STM8S_Periph
    ../../StdPeriph/inc/: stm8s.h stm8s_adc1.h stm8s_awu.h stm8s_beep.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_uart2.h stm8s_wwdg.h
    ../../StdPeriph/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
